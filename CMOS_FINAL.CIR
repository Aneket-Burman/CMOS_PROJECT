CIRCUIT D:\Windows Softwares\Microwind 3.1 Full\Microwind 3.1 Full\examples\CMOS_FINAL.MSK
*
* IC Technology: CMOS 0.18µm - 6 Metal
*
VDD 1 0 DC 2.00
V2_Vdd 2 0 DC 2.50V
V3_Vdd 3 0 DC 2.50V
V4_Vdd 4 0 DC 2.50V
V5_Vdd 5 0 DC 2.50V
V6_Vdd 6 0 DC 2.50V
V7_Vdd 7 0 DC 2.50V
V8_Vdd 8 0 DC 2.50V
V9_Vdd 9 0 DC 2.50V
V10_Vdd 10 0 DC 2.50V
V11_Vdd 11 0 DC 2.50V
V12_Vdd 12 0 DC 2.50V
V13_Vdd 13 0 DC 2.50V
V14_Vdd 14 0 DC 2.50V
V15_Vdd 15 0 DC 2.50V
V16_Vdd 16 0 DC 2.50V
V17_Vdd 17 0 DC 2.50V
V18_Vdd 18 0 DC 2.50V
V19_Vdd 19 0 DC 2.50V
VB1 29 0 DC 0 PULSE(0.00 5.00 1.95N 0.05N 0.05N 1.95N 4.00N)
VB1 35 0 DC 0 PULSE(0.00 5.00 1.95N 0.05N 0.05N 1.95N 4.00N)
VB0 42 0 DC 0 PULSE(0.00 5.00 0.95N 0.05N 0.05N 0.95N 2.00N)
VB0 46 0 DC 0 PULSE(0.00 5.00 0.95N 0.05N 0.05N 0.95N 2.00N)
VA0 65 0 DC 0 PULSE(0.00 5.00 0.45N 0.05N 0.05N 0.45N 1.00N)
VA1 66 0 DC 0 PULSE(0.00 5.00 0.20N 0.05N 0.05N 0.20N 0.50N)
VA0 67 0 DC 0 PULSE(0.00 5.00 0.45N 0.05N 0.05N 0.45N 1.00N)
VA1 68 0 DC 0 PULSE(0.00 5.00 0.20N 0.05N 0.05N 0.20N 0.50N)
*
* List of nodes
* "P2" corresponds to n°22
* "P3" corresponds to n°26
* "B1" corresponds to n°29, WARNING: appears 2 times in the layout
* "P1" corresponds to n°33
* "B1" corresponds to n°35, WARNING: appears 2 times in the layout
* "B0" corresponds to n°42, WARNING: appears 2 times in the layout
* "P0" corresponds to n°45
* "B0" corresponds to n°46, WARNING: appears 2 times in the layout
* "A0" corresponds to n°65, WARNING: appears 2 times in the layout
* "A1" corresponds to n°66, WARNING: appears 2 times in the layout
* "A0" corresponds to n°67, WARNING: appears 2 times in the layout
* "A1" corresponds to n°68, WARNING: appears 2 times in the layout
*
* MOS devices
MN1 0 30 20 0 N1  W= 1.00U L= 0.20U
MN2 20 23 26 0 N1  W= 1.00U L= 0.20U
MN3 0 27 26 0 N1  W= 1.00U L= 0.20U
MN4 0 23 24 0 N1  W= 1.00U L= 0.20U
MN5 24 20 22 0 N1  W= 1.00U L= 0.20U
MN6 49 24 20 0 N1  W= 1.00U L= 0.20U
MN7 53 23 27 0 N1  W= 1.00U L= 0.20U
MN8 29 68 20 0 N1  W= 1.00U L= 0.20U
MN9 54 68 30 0 N1  W= 1.00U L= 0.20U
MN10 55 38 23 0 N1  W= 1.00U L= 0.20U
MN11 0 36 23 0 N1  W= 1.00U L= 0.20U
MN12 38 23 33 0 N1  W= 1.00U L= 0.20U
MN13 35 67 23 0 N1  W= 1.00U L= 0.20U
MN14 57 67 36 0 N1  W= 1.00U L= 0.20U
MN15 0 40 23 0 N1  W= 1.00U L= 0.20U
MN16 0 34 38 0 N1  W= 1.00U L= 0.20U
MN17 0 43 34 0 N1  W= 1.00U L= 0.20U
MN18 61 34 40 0 N1  W= 1.00U L= 0.20U
MN19 42 66 34 0 N1  W= 1.00U L= 0.20U
MN20 62 66 43 0 N1  W= 1.00U L= 0.20U
MN21 0 47 45 0 N1  W= 1.00U L= 0.20U
MN22 46 65 45 0 N1  W= 1.00U L= 0.20U
MN23 64 65 47 0 N1  W= 1.00U L= 0.20U
MP1 21 23 20 14 P1  W= 1.00U L= 0.20U
MP2 23 20 22 13 P1  W= 1.00U L= 0.20U
MP3 1 23 24 19 P1  W= 1.00U L= 0.20U
MP4 20 27 26 16 P1  W= 1.00U L= 0.20U
MP5 1 23 27 15 P1  W= 1.00U L= 0.20U
MP6 29 30 20 18 P1  W= 1.00U L= 0.20U
MP7 1 68 30 17 P1  W= 1.00U L= 0.20U
MP8 32 34 23 10 P1  W= 1.00U L= 0.20U
MP9 34 23 33 11 P1  W= 1.00U L= 0.20U
MP10 35 36 23 8 P1  W= 1.00U L= 0.20U
MP11 1 67 36 9 P1  W= 1.00U L= 0.20U
MP12 1 34 38 12 P1  W= 1.00U L= 0.20U
MP13 1 34 40 7 P1  W= 1.00U L= 0.20U
MP14 42 43 34 5 P1  W= 1.00U L= 0.20U
MP15 1 66 43 4 P1  W= 1.00U L= 0.20U
MP16 46 47 45 2 P1  W= 1.00U L= 0.20U
MP17 1 65 47 3 P1  W= 1.00U L= 0.20U
*
C2 2 0  1.540fF
C3 3 0  1.540fF
C4 4 0  1.540fF
C5 5 0  1.540fF
C6 6 0  1.540fF
C7 7 0  1.540fF
C8 8 0  1.540fF
C9 9 0  1.540fF
C10 10 0  1.540fF
C11 11 0  1.540fF
C12 12 0  1.540fF
C13 13 0  1.540fF
C14 14 0  1.540fF
C15 15 0  1.540fF
C16 16 0  1.540fF
C17 17 0  1.540fF
C18 18 0  1.540fF
C19 19 0  1.540fF
C20 20 0 10.055fF
C21 21 0  0.531fF
C22 22 0  1.445fF
C23 23 0 20.092fF
C24 24 0  3.463fF
C25 1 0  0.531fF
C26 26 0  2.990fF
C27 27 0  2.729fF
C28 1 0  0.531fF
C29 29 0  1.198fF
C30 30 0  2.729fF
C31 1 0  0.531fF
C32 32 0  0.531fF
C33 33 0  1.533fF
C34 34 0  5.547fF
C35 35 0  1.198fF
C36 36 0  2.721fF
C37 1 0  0.531fF
C38 38 0  3.244fF
C39 1 0  0.531fF
C40 40 0  2.727fF
C41 1 0  0.531fF
C42 42 0  1.198fF
C43 43 0  2.631fF
C44 1 0  0.531fF
C45 45 0  2.990fF
C46 46 0  1.198fF
C47 47 0  2.729fF
C48 1 0  0.531fF
C49 49 0  0.566fF
C53 53 0  0.566fF
C54 54 0  0.566fF
C55 55 0  0.566fF
C57 57 0  0.566fF
C61 61 0  0.566fF
C62 62 0  0.566fF
C64 64 0  0.566fF
C65 65 0  0.178fF
C66 66 0  0.190fF
C67 67 0  0.181fF
C68 68 0  0.184fF
*
*
* n-MOS BSIM4 :
* low leakage
.MODEL N1 NMOS LEVEL=14 VTHO=0.55 U0=0.038 TOXE= 4.0E-9 LINT=-0.010U
+K1 =0.170 K2=0.100 DVT0=2.300
+DVT1=0.540 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  1.7 U0=0.038 UA=2.800e-15
+WINT=0.020U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=0.290
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* p-MOS BSIM4:
* low leakage
.MODEL P1 PMOS LEVEL=14 VTHO=-0.60 U0=0.010 TOXE= 4.0E-9 LINT=-0.040U
+K1 =0.290 K2=0.100 DVT0=2.300
+DVT1=0.540 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  2.2 U0=0.010 UA=1.000e-15
+WINT=0.020U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=0.300
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 5.00N
print  V(46) V(26) V(66) V(42) V(45) V(67) V(35) V(68) V(29) V(33) V(22) > out.txt
plot  V(46) V(26) V(66) V(42) V(45) V(67) V(35) V(68) V(29) V(33) V(22)
.endc
.END
